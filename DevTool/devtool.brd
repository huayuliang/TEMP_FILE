# Repository huayuliang/TEMP_FILE

## EAGLE design DevTool/devtool.brd

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17: 100nF/50V; C0603
IC1, IC2, IC3: SGM8584XS14; SOIC-14
IC4: 7805T; TO220H
IC5: TL431; SOT23-3
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12: NPN; SOT23-BEC
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: R0603
R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25: 10K; R0603
RP1, RP2, RP3, RP4, RP5, RP6, RP7, RP8, RP9, RP10, RP11, RP12: 20K; RM065
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20: PB-22E60

Connections:
+5V: C13.1, C14.1, C15.1, C16.1, IC1.4 (V+), IC2.4 (V+), IC3.4 (V+), IC4.3 (VO), Q1.C, Q2.C, Q3.C, Q4.C, Q5.C, Q6.C, Q8.C, Q9.C, Q10.C, Q11.C, Q12.C, R25.2
+24V: C17.1, IC4.1 (VI), SW1.2, SW1.5, SW2.2, SW2.5, SW3.2, SW3.5, SW4.2, SW4.5, SW5.2, SW6.2, SW7.2, SW8.2, SW8.3, SW8.5, SW8.6, SW9.2, SW9.5, SW10.2, SW10.5, SW11.2, SW11.5, SW12.2, SW12.5, SW13.2, SW14.2, SW14.5, SW15.2, SW15.5, SW16.2, SW16.3, SW16.6, SW17.2, SW17.5, SW18.2, SW18.5, SW19.2, SW19.5, SW20.2, SW20.5
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, IC1.11 (V-), IC2.11 (V-), IC3.11 (V-), IC4.2 (GND), IC5.3 (A), RP1.1, RP2.1, RP3.1, RP4.1, RP5.1, RP6.1, RP7.1, RP8.1, RP9.1, RP10.1, RP11.1, RP12.1
unnamed: SW12.3, SW12.6
unnamed: IC1.1 (OUT), Q1.B, R1.1
unnamed: IC1.7 (OUT), Q2.B, R2.1
unnamed: IC1.8 (OUT), Q3.B, R3.1
unnamed: IC1.14 (OUT), Q4.B, R4.1
unnamed: IC2.1 (OUT), Q5.B, R5.1
unnamed: IC2.7 (OUT), Q6.B, R6.1
unnamed: IC2.8 (OUT), Q7.B, R7.1
unnamed: IC2.14 (OUT), Q8.B, R8.1
unnamed: IC3.1 (OUT), Q9.B, R9.1
unnamed: IC3.7 (OUT), Q10.B, R10.1
unnamed: IC3.8 (OUT), Q11.B, R11.1
unnamed: IC3.14 (OUT), Q12.B, R12.1
unnamed: IC1.2 (-IN), Q1.E, R1.2
unnamed: IC3.13 (-IN), Q12.E, R12.2
unnamed: IC3.9 (-IN), Q11.E, R11.2
unnamed: IC3.6 (-IN), Q10.E, R10.2
unnamed: IC3.2 (-IN), Q9.E, R9.2
unnamed: IC1.6 (-IN), Q2.E, R2.2
unnamed: IC1.9 (-IN), Q3.E, R3.2
unnamed: IC1.13 (-IN), Q4.E, R4.2
unnamed: IC2.2 (-IN), Q5.E, R5.2
unnamed: IC2.6 (-IN), Q6.E, R6.2
unnamed: IC2.9 (-IN), Q7.E, R7.2
unnamed: IC2.13 (-IN), Q8.E, R8.2
unnamed: SW14.3, SW14.6
unnamed: SW14.1, SW14.4
unnamed: SW13.1, SW13.4
unnamed: SW15.1, SW15.4
unnamed: SW15.3, SW15.6
unnamed: SW16.1, SW16.4
unnamed: SW8.1, SW8.4
unnamed: SW7.3, SW7.6
unnamed: SW7.1, SW7.4
unnamed: SW6.3, SW6.6
unnamed: SW6.1, SW6.4
unnamed: SW5.3, SW5.6
unnamed: SW5.1, SW5.4
unnamed: SW4.3, SW4.6
unnamed: SW4.1, SW4.4
unnamed: SW3.1, SW3.4
unnamed: SW3.3, SW3.6
unnamed: SW2.1, SW2.4
unnamed: SW2.3, SW2.6
unnamed: SW1.3, SW1.6
unnamed: SW1.1, SW1.4
unnamed: SW9.1, SW9.4
unnamed: SW9.3, SW9.6
unnamed: SW10.1, SW10.4
unnamed: SW10.3, SW10.6
unnamed: SW11.1, SW11.4
unnamed: SW11.3, SW11.6
unnamed: SW12.1, SW12.4
unnamed: C1.1, R13.1, RP1.3
unnamed: C2.1, R14.1, RP2.3
unnamed: C3.1, R15.1, RP3.3
unnamed: C4.1, R16.1, RP4.3
unnamed: C5.1, R17.1, RP5.3
unnamed: C6.1, R18.1, RP6.3
unnamed: C7.1, R19.1, RP7.3
unnamed: C8.1, R20.1, RP8.3
unnamed: C9.1, R21.1, RP9.3
unnamed: C10.1, R22.1, RP10.3
unnamed: C11.1, R23.1, RP11.3
unnamed: C12.1, R24.1, RP12.3
unnamed: IC1.3 (+IN), R13.2
unnamed: IC1.5 (+IN), R14.2
unnamed: IC1.10 (+IN), R15.2
unnamed: IC1.12 (+IN), R16.2
unnamed: IC2.12 (+IN), R20.2
unnamed: IC2.10 (+IN), R19.2
unnamed: IC2.5 (+IN), R18.2
unnamed: IC2.3 (+IN), R17.2
unnamed: IC3.3 (+IN), R21.2
unnamed: IC3.5 (+IN), R22.2
unnamed: IC3.10 (+IN), R23.2
unnamed: IC3.12 (+IN), R24.2
REF: IC5.1 (C), IC5.2 (REF), R25.1, RP1.2, RP2.2, RP3.2, RP4.2, RP5.2, RP6.2, RP7.2, RP8.2, RP9.2, RP10.2, RP11.2, RP12.2

Board: 2 copper layers, 91 parts (0 on the bottom side), 81 nets, no tracks yet.

## EAGLE design PannelInterface/PannelInterface.brd

Parts:
C1, C4: 100n/50V; C0805
C2: 220uF/35V; TT5D11
C3: 330uF/16V; UD-8X10_NICHICON
CON1: XH-8AW
CON2: PH-8AW
D1: SS24; DO214AA
DB1: DB207S; DBS
IC1: LM2575D2T-012; DDPAK-5_MICROCHIP
L1: 330uH/2A_RH127; MSS1260
LOGO1: SY-LOGO_BOTTOM
X1: F09HP

Connections:
+12V: C3.+, C4.1, CON1.1, CON1.2, CON2.1, CON2.2, IC1.4, L1.2
AC1: DB1.AC2, X1.6, X1.7
AC2: DB1.AC1, X1.8, X1.9
GND: C1.2, C2.-, C3.-, C4.2, CON1.7, CON1.8, CON2.7, CON2.8, D1.A, DB1.-, IC1.3, IC1.5, IC1.6 (3), X1.5, X1.G1, X1.G2
unnamed: C1.1, C2.+, DB1.+, IC1.1
unnamed: D1.C, IC1.2, L1.1
RXD: CON1.5, CON1.6, CON2.6, X1.2
TXD: CON1.4, CON2.5, X1.3

Notes on the sheet:
DIN
DOUT
232-DOUT
232-DIN
485+
485-
BUSY
触摸屏转接适配板

Board: 2 copper layers, 36.0 x 100.0 mm, 13 parts (0 on the bottom side), 8 nets.

Other parts of the board:
U$1: PANNEL-INTERFACE-OUTLINE

## EAGLE design snowmaker/SnowMaker_V1.0.brd

Parts:
BAT1: CR2032/1HF; CR2032-HF
C1: 1nF/2kV; C1206
C2, C3, C9, C10, C11, C16, C17, C18, C24, C25, C26, C28, C29, C32, C33, C34, C35, C36, C37, C38, C40, C41, C43, C45, C46: 100nF/50V; C0603
C4, C5: 6.8nF/50V; C0603
C6, C15: 10nF/50V; C0603
C7, C23, C30, C42: 10uF/16V; C0603
C8: 22nF/50V; C0603
C12, C14, C19, C20, C21, C31: 100uF/6.3V 5x5.8; UD-5X5,8_NICHICON
C13: 4.7uF/10V; C0603
C22, C27: 18pF/50V; C0603
C39, C44: 6.8pF/50V/NP0; C0603
C47, C48: 18pF/50V/NP0; C0603
CON1: HR951180A; HY951180A
CON2: SWJ; PINHEAD-4P
D1: SM712-02H; SOT23-3
F1, F2: TRF250-120T
F3: RXEF110
IC1: ST3232BD; SO16
IC2: ST3485EBD; SO08
IC3: W5500; LQFP48_7X7_0.5P
IC4: SD2068; SOIC-8
IC5: STM32F103VCT6; LQFP100_14X14MM
L1, L2, L4, L7: 600R/100MHz; L0603
L3: 100R/100MHz 3A; L0603
L5, L6: 100R/100MHz; L0805
LED1, LED2: LEDSML0805; SML0805
LED3: LED0805
LOGO1: SY-LOGO_BOTTOM
R1: 0R; R1206
R2, R5: 22R; R0603
R3, R4, R24, R25: 330R; R0603
R6, R12, R17, R23, R26, R27, R28, R29, R30, R31, R32, R33, R35, R36, R37, R38, R39: 10k; R0603
R7, R8, R9, R11: 49R9; R0603
R10: 10R; R0603
R13: 120R; R1206
R14, R15: 2.4k; R0603
R16: 12.4k/1%; R0603
R18, R19, R20, R22: 0R; R0603
R21: 1M; R0603
R34: 1k; R0603
U1: LQ-BTM2540
X1: F09VP
XT1: FFKDS/V1-5.08-2
XT2: FFKDS/V1-5.08-3
XTAL1: 25MHz; SM49
XTAL2: MC-306 32.768000kHz 12.5 +20.0-20.0; MC306
XTAL3: 8MHz; SM49

Connections:
1V20: C15.1, IC3.22 (1V2O)
+3V3: C12.+, C14.+, C17.1, C18.1, C19.+, C20.+, C32.1, C33.1, C34.1, C35.1, C37.1, C38.1, C41.1, C43.1, C45.1, CON1.9, CON1.12, CON2.1 (VDD), IC3.28 (VDD), IC5.6 (VBAT), IC5.11 (VDD), IC5.28 (VDD), IC5.50 (VDD), IC5.75 (VDD), IC5.100 (VDD), L1.2, L2.2, L3.1, L4.1, L5.2, L6.2, L7.1, R23.2, R26.2, R28.2, R30.2, R38.2; also elsewhere on the board
ACTLED: IC3.27 (ACTLED), R25.2
ADCIN0: IC5.23 (PA0-WKUP); also elsewhere on the board
ADCIN1: IC5.24 (PA1); also elsewhere on the board
ADCIN2: IC5.25 (PA2); also elsewhere on the board
ADCIN3: IC5.26 (PA3); also elsewhere on the board
ADCIN4: IC5.29 (PA4); also elsewhere on the board
ADCIN5: IC5.30 (PA5); also elsewhere on the board
ADCIN6: IC5.31 (PA6); also elsewhere on the board
ADCIN7: IC5.32 (PA7); also elsewhere on the board
ADCIN8: IC5.35 (PB0); also elsewhere on the board
ADCIN9: IC5.36 (PB1); also elsewhere on the board
ADCIN10: IC5.15 (PC0); also elsewhere on the board
ADCIN11: IC5.16 (PC1); also elsewhere on the board
AGND: IC5.19 (VSSA), IC5.20 (VREF-); also elsewhere on the board
BOOT0: IC5.94 (BOOT0), R39.2
BTM-!ATC: IC5.89 (PB3), U1.6 (P2.0)
BTM-LINK: IC5.88 (PD7), U1.15 (P1.1)
BTM-RX: IC5.86 (PD5), U1.22 (P0.2/RX)
BTM-TX: IC5.87 (PD6), U1.21 (P0.3/TX)
BTM-WORK_STATUS: R34.1, U1.16 (P1.0)
DIN1: IC5.97 (PE0); also elsewhere on the board
DIN2: IC5.98 (PE1); also elsewhere on the board
DIN3: IC5.1 (PE2); also elsewhere on the board
DIN4: IC5.2 (PE3); also elsewhere on the board
DIN5: IC5.3 (PE4); also elsewhere on the board
DIN6: IC5.4 (PE5); also elsewhere on the board
DIN7: IC5.5 (PE6); also elsewhere on the board
DIN8: IC5.38 (PE7); also elsewhere on the board
DIN9: IC5.39 (PE8); also elsewhere on the board
DIN10: IC5.40 (PE9); also elsewhere on the board
DIN11: IC5.41 (PE10); also elsewhere on the board
DIN12: IC5.42 (PE11); also elsewhere on the board
DIN13: IC5.43 (PE12); also elsewhere on the board
DIN14: IC5.44 (PE13); also elsewhere on the board
DIN15: IC5.45 (PE14); also elsewhere on the board
DIN16: IC5.46 (PE15); also elsewhere on the board
DIN17: IC5.17 (PC2); also elsewhere on the board
DIN18: IC5.18 (PC3); also elsewhere on the board
DIN19: IC5.33 (PC4); also elsewhere on the board
DIN20: IC5.34 (PC5); also elsewhere on the board
DOUT1: IC5.81 (PD0); also elsewhere on the board
DOUT2: IC5.82 (PD1); also elsewhere on the board
DOUT3: IC5.83 (PD2); also elsewhere on the board
DOUT4: IC5.84 (PD3); also elsewhere on the board
DOUT5: IC5.85 (PD4); also elsewhere on the board
DOUT6: IC5.58 (PD11); also elsewhere on the board
DOUT7: IC5.59 (PD12); also elsewhere on the board
DOUT8: IC5.60 (PD13); also elsewhere on the board
DOUT9: IC5.61 (PD14); also elsewhere on the board
DOUT10: IC5.62 (PD15); also elsewhere on the board
DOUT11: IC5.63 (PC6); also elsewhere on the board
DOUT12: IC5.64 (PC7); also elsewhere on the board
DOUT13: IC5.65 (PC8); also elsewhere on the board
DOUT14: IC5.66 (PC9); also elsewhere on the board
DOUT15: IC5.78 (PC10); also elsewhere on the board
DOUT16: IC5.79 (PC11); also elsewhere on the board
DOUT17: IC5.80 (PC12); also elsewhere on the board
DOUT18: IC5.90 (PB4); also elsewhere on the board
DOUT19: IC5.95 (PB8); also elsewhere on the board
DOUT20: IC5.96 (PB9); also elsewhere on the board
DOUT21: IC5.67 (PA8); also elsewhere on the board
DOUT22: IC5.70 (PA11); also elsewhere on the board
DOUT23: IC5.71 (PA12); also elsewhere on the board
DOUT24: IC5.77 (PA15); also elsewhere on the board
DUPLED: IC3.26 (DUPLED), R24.2
ETHSPI_MISO: IC3.34 (MISO), IC5.53 (PB14)
ETHSPI_MOSI: IC3.35 (MOSI), IC5.54 (PB15)
ETHSPI_NSS: IC3.32 (!SCS), IC5.51 (PB12)
ETHSPI_SCK: IC3.33 (SCLK), IC5.52 (PB13)
ETH_!INT: IC3.36 (!INT), IC5.47 (PB10)
ETH_!RST: IC3.37 (RST_N), IC5.48 (PB11)
ETH_RXC_N: C4.1, CON1.6
ETH_RXC_P: C5.1, CON1.3
ETH_RX_N: C4.2, IC3.5 (RXN), R9.1
ETH_RX_P: C5.2, IC3.6 (RXP), R11.1
ETH_TX_N: CON1.2, IC3.1 (TXN), R8.2
ETH_TX_P: CON1.1, IC3.2 (TXP), R7.2
ETH_XI: C22.1, IC3.30 (XI/CLKIN), R21.1, XTAL1.1
ETH_XO: IC3.31 (XO), R21.2, R22.2
EXRES1: IC3.10 (EXRES1), R16.1
GND: BAT1.B-, C1.2, C2.2, C3.2, C6.2, C7.2, C8.2, C9.2, C12.-, C13.2, C14.-, C15.2, C16.2, C17.2, C18.2, C19.-, C20.-, C21.-, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.-, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, CON2.4 (GND), D1.3, IC1.15 (GND), IC2.5 (GND), IC3.3 (AGND), IC3.9 (AGND), IC3.14 (AGND), IC3.16 (AGND), IC3.19 (AGND), IC3.29 (GND), IC3.48 (AGND), IC4.4 (GND), IC5.10 (VSS), IC5.27 (VSS), IC5.49 (VSS), IC5.74 (VSS), IC5.99 (VSS), LED1.C, LED2.C, LED3.C, R1.1, R6.1, R12.1, R15.1, R16.2, R17.1, R27.1, R29.1, R31.1, R32.1, R33.1, R39.1, U1.2 (GND), X1.5, XT2.3@1, XT2.3@2; also elsewhere on the board
LINKLED: IC3.25 (LINKLED), R3.2
MCU_NRST: C46.1, IC5.14 (NRST), R38.1
MCU_OSC_IN: C47.1, IC5.12 (OSC_IN), XTAL3.1
MCU_OSC_OUT: C48.1, IC5.13 (OSC_OUT), XTAL3.2
unnamed: F3.1, XT1.1@1, XT1.1@2
unnamed: F1.1, XT2.1@1, XT2.1@2
unnamed: F2.1, XT2.2@1, XT2.2@2
unnamed: F3.2, X1.8, X1.9
unnamed: X1.6, X1.7, XT1.2@1, XT1.2@2
unnamed: C27.1, R22.1, XTAL1.2
unnamed: CON1.10, R3.1
unnamed: C10.2, IC1.1 (C1+)
unnamed: C11.2, IC1.4 (C2+)
unnamed: C2.1, IC1.2 (V+)
unnamed: C3.1, IC1.6 (V-)
unnamed: C10.1, IC1.3 (C1-)
unnamed: C11.1, IC1.5 (C2-)
unnamed: IC2.4 (DI), R20.1
unnamed: CON1.11, R4.1
unnamed: IC1.10 (T2IN), R12.2
unnamed: IC2.2 (!RE), IC2.3 (DE), R19.1
unnamed: IC1.14 (T1OUT), R2.2
unnamed: R2.1, X1.2
unnamed: C1.1, CON1.SS@1 (SHIELD), CON1.SS@2 (SHIELD)
unnamed: C8.1, CON1.4, R10.1
unnamed: C6.1, CON1.5, R9.2, R11.2
unnamed: R5.1, X1.3
unnamed: LED1.A, R25.1
unnamed: LED2.A, R24.1
unnamed: IC1.13 (R1IN), R5.2
unnamed: IC1.8 (R2IN), R6.2
unnamed: LED3.A, R34.2
unnamed: BAT1.B+, C36.1, IC4.3 (VBAT)
unnamed: R23.1, U1.3 (!RST)
unnamed: C7.1, C9.1, IC1.16 (VCC), L1.1
unnamed: C23.1, C25.1, L4.2, U1.1 (VCC)
unnamed: C16.1, IC2.8 (VCC), L2.1, R14.2
unnamed: R1.2, X1.G1
unnamed: C40.1, C42.1, IC4.8 (VDD), L7.2, R35.1, R36.1, R37.1
PMODE0: IC3.45 (PMODE0), R26.1
PMODE1: IC3.44 (PMODE1), R28.1
PMODE2: IC3.43 (PMODE2), R30.1
RS485-A: D1.2, F2.2, IC2.6 (A), R13.1, R15.2
RS485-B: D1.1, F1.2, IC2.7 (B), R13.2, R14.1
RSVD1: IC3.38 (RSVD), R27.2
RSVD2: IC3.39 (RSVD), R29.2
RSVD3: IC3.40 (RSVD), R31.2
RSVD4: IC3.41 (RSVD), R32.2
RSVD5: IC3.42 (RSVD), R33.2
RSVD6: IC3.23 (RSVD), R17.2
RTC-INT: IC4.7 (INT), IC5.91 (PB5), R35.2
RTC-SCL: IC4.6 (SCL), IC5.92 (PB6), R36.2
RTC-SDA: IC4.5 (SDA), IC5.93 (PB7), R37.2
RTC_OSCIN: C39.1, IC4.1 (OSCIN), XTAL2.4 (2)
RTC_OSCOUT: C44.1, IC4.2 (OSCOUT), XTAL2.1
RX-485: IC2.1 (RO), R18.1
SPDLED: IC3.24 (SPDLED), R4.2
SYS_JTMS-SWCLK: CON2.3 (SWCLK), IC5.76 (PA14)
SYS_JTMS-SWDIO: CON2.2 (SWDIO), IC5.72 (PA13)
TLCMP-RX: IC1.12 (R1OUT), IC5.69 (PA10)
TLCMP-TX: IC1.11 (T1IN), IC5.68 (PA9)
TOCAP: C13.1, IC3.20 (TOCAP)
VCCA_3V3: C31.+, IC5.22 (VDDA), L5.1, L6.1; also elsewhere on the board
VCCRF: C21.+, C24.1, C26.1, C28.1, C29.1, C30.1, IC3.4 (AVDD), IC3.8 (AVDD), IC3.11 (AVDD), IC3.15 (AVDD), IC3.17 (AVDD), IC3.21 (AVDD), L3.2, R7.1, R8.1, R10.2
VREF_2.5V_ADC: IC5.21 (VREF+); also elsewhere on the board
WI_RS485-R/W: IC5.57 (PD10), R19.2
WI_RS485-RX: IC5.56 (PD9), R18.2
WI_RS485-TX: IC5.55 (PD8), R20.2

Notes on the sheet:
SPI MODE 0 and MODE 3
网络连接指示灯（Link LED） 显示当前连接状态： 低电平：连接建立； 高电平：未连接；
全/半双工指示灯（Duplex LED） 显示当前连接的双工状态： 低电平：全双工状态； 高电平：半双工状态；
活动状态指示灯（Active LED） 显示数据收/发活动时，物理介质子层载波侦听活动情况： 低电平：有物理介质子层的载波侦听信号； 高电平：无物理介质子层的载波侦听信号；
网络速度指示灯（Speed LED） 显示当前连接的网络速度状态： 低电平：100Mbps；高电平：10Mbps
绿灯：长亮-代表100M； 不亮-代表10M 黄灯：长亮-代表无数据收发； 闪烁-代表有数据收发
weather instrument
至迪文触摸屏 低温，两个版本（-30、-40） 需要对端板做供电，无需做电平转换。
RXD_IN
TXD_OUT
以太网
气象仪接口 - RS485
触摸屏接口 - RS232
晶体单元 https://item.taobao.com/item.htm?spm=a230r.1.14.133.76bf5232kHdgc&id=531767386586&ns=1&abbucket=16#detail
SMA 转 IPEX 接口 长线
蓝牙模块
默认为 从模式 9600 8N1 无流控 没有开取鉴权
USART2-RX
USART2-TX
USART3_RX
USART3_TX
因触摸屏上有实时时钟，这部分可能会取消
RTC
XT1 15VAC/1A Power Supply
参考：
