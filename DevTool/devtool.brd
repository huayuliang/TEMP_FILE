# Repository huayuliang/TEMP_FILE (continued)

## EAGLE design snowmaker/SnowMaker_V1.0.brd (continued)

Parts:
C49, C50, C51, C52, C53, C54, C55, C56, C60, C61, C62, C63, C64, C65, C66, C67, C69, C70, C71, C72, C73, C74, C75, C76: 10nF/50V; C0603
C57, C58, C59, C68, C77: 100nF/50V; C0603
CON3: CON-HARTING-26V; 26V
EC1, EC2, EC3: 220uF/50V; UD-8X10_NICHICON
IC6, IC7, IC8: ULN2803; SO18W
OK1, OK2, OK3, OK4, OK5, OK6: TLP283-4; MINI-FLAT-16
R40, R41, R42, R43, R44, R45, R46, R47, R56, R57, R58, R59, R60, R61, R62, R63, R72, R73, R74, R75, R76, R77, R78, R79: 330R; R0603
R48, R49, R50, R51, R52, R53, R54, R55, R64, R65, R66, R67, R68, R69, R70, R71, R80, R81, R82, R83, R84, R85, R86, R87: 20K; R0603

Connections:
+24V: C57.1, C58.1, C59.1, C68.1, C77.1, CON3.B1, EC1.+, EC2.+, EC3.+, IC6.10 (CD+), IC7.10 (CD+), IC8.10 (CD+), R48.1, R49.1, R50.1, R51.1, R52.1, R53.1, R54.1, R55.1, R64.1, R65.1, R66.1, R67.1, R68.1, R69.1, R70.1, R71.1, R80.1, R81.1, R82.1, R83.1, R84.1, R85.1, R86.1, R87.1
DOUT1: R40.2; also elsewhere on the board
DOUT2: R41.2; also elsewhere on the board
DOUT3: R42.2; also elsewhere on the board
DOUT4: R43.2; also elsewhere on the board
DOUT5: R44.2; also elsewhere on the board
DOUT6: R45.2; also elsewhere on the board
DOUT7: R46.2; also elsewhere on the board
DOUT8: R47.2; also elsewhere on the board
DOUT9: R56.2; also elsewhere on the board
DOUT10: R57.2; also elsewhere on the board
DOUT11: R58.2; also elsewhere on the board
DOUT12: R59.2; also elsewhere on the board
DOUT13: R60.2; also elsewhere on the board
DOUT14: R61.2; also elsewhere on the board
DOUT15: R62.2; also elsewhere on the board
DOUT16: R63.2; also elsewhere on the board
DOUT17: R72.2; also elsewhere on the board
DOUT18: R73.2; also elsewhere on the board
DOUT19: R74.2; also elsewhere on the board
DOUT20: R75.2; also elsewhere on the board
DOUT21: R76.2; also elsewhere on the board
DOUT22: R77.2; also elsewhere on the board
DOUT23: R78.2; also elsewhere on the board
DOUT24: R79.2; also elsewhere on the board
GND: OK1.2 (C), OK1.4 (C), OK1.6 (C), OK1.8 (C), OK2.2 (C), OK2.4 (C), OK2.6 (C), OK2.8 (C), OK3.2 (C), OK3.4 (C), OK3.6 (C), OK3.8 (C), OK4.2 (C), OK4.4 (C), OK4.6 (C), OK4.8 (C), OK5.2 (C), OK5.4 (C), OK5.6 (C), OK5.8 (C), OK6.2 (C), OK6.4 (C), OK6.6 (C), OK6.8 (C); also elsewhere on the board
GND1: C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, CON3.A1, EC1.-, EC2.-, EC3.-, IC6.9 (GND), IC7.9 (GND), IC8.9 (GND)
unnamed: C49.1, IC6.1 (I1), OK1.15 (EMIT)
unnamed: C50.1, IC6.2 (I2), OK1.13 (EMIT)
unnamed: C51.1, IC6.3 (I3), OK1.11 (EMIT)
unnamed: C52.1, IC6.4 (I4), OK1.9 (EMIT)
unnamed: C53.1, IC6.5 (I5), OK2.15 (EMIT)
unnamed: C54.1, IC6.6 (I6), OK2.13 (EMIT)
unnamed: C55.1, IC6.7 (I7), OK2.11 (EMIT)
unnamed: C56.1, IC6.8 (I8), OK2.9 (EMIT)
unnamed: C60.1, IC7.1 (I1), OK3.15 (EMIT)
unnamed: C61.1, IC7.2 (I2), OK3.13 (EMIT)
unnamed: C62.1, IC7.3 (I3), OK3.11 (EMIT)
unnamed: C63.1, IC7.4 (I4), OK3.9 (EMIT)
unnamed: C64.1, IC7.5 (I5), OK4.15 (EMIT)
unnamed: C65.1, IC7.6 (I6), OK4.13 (EMIT)
unnamed: C66.1, IC7.7 (I7), OK4.11 (EMIT)
unnamed: C67.1, IC7.8 (I8), OK4.9 (EMIT)
unnamed: C76.1, IC8.8 (I8), OK6.9 (EMIT)
unnamed: C69.1, IC8.1 (I1), OK5.15 (EMIT)
unnamed: C70.1, IC8.2 (I2), OK5.13 (EMIT)
unnamed: C71.1, IC8.3 (I3), OK5.11 (EMIT)
unnamed: C72.1, IC8.4 (I4), OK5.9 (EMIT)
unnamed: C73.1, IC8.5 (I5), OK6.15 (EMIT)
unnamed: C74.1, IC8.6 (I6), OK6.13 (EMIT)
unnamed: C75.1, IC8.7 (I7), OK6.11 (EMIT)
unnamed: OK1.16 (COL), R48.2
unnamed: OK1.14 (COL), R49.2
unnamed: OK1.12 (COL), R50.2
unnamed: OK1.10 (COL), R51.2
unnamed: OK2.16 (COL), R52.2
unnamed: OK2.14 (COL), R53.2
unnamed: OK2.12 (COL), R54.2
unnamed: OK2.10 (COL), R55.2
unnamed: OK3.16 (COL), R64.2
unnamed: OK3.14 (COL), R65.2
unnamed: OK3.12 (COL), R66.2
unnamed: OK3.10 (COL), R67.2
unnamed: OK4.16 (COL), R68.2
unnamed: OK4.14 (COL), R69.2
unnamed: OK4.12 (COL), R70.2
unnamed: OK4.10 (COL), R71.2
unnamed: OK1.1 (A), R40.1
unnamed: OK1.3 (A), R41.1
unnamed: OK1.5 (A), R42.1
unnamed: OK5.16 (COL), R80.2
unnamed: OK5.14 (COL), R81.2
unnamed: OK5.12 (COL), R82.2
unnamed: OK5.10 (COL), R83.2
unnamed: OK6.16 (COL), R84.2
unnamed: OK6.14 (COL), R85.2
unnamed: OK6.12 (COL), R86.2
unnamed: OK6.10 (COL), R87.2
unnamed: OK1.7 (A), R43.1
unnamed: OK2.1 (A), R44.1
unnamed: OK2.3 (A), R45.1
unnamed: OK2.5 (A), R46.1
unnamed: OK2.7 (A), R47.1
unnamed: OK3.1 (A), R56.1
unnamed: OK3.3 (A), R57.1
unnamed: OK3.5 (A), R58.1
unnamed: OK5.1 (A), R72.1
unnamed: OK5.3 (A), R73.1
unnamed: OK5.5 (A), R74.1
unnamed: OK5.7 (A), R75.1
unnamed: OK6.1 (A), R76.1
unnamed: OK6.3 (A), R77.1
unnamed: OK6.5 (A), R78.1
unnamed: OK6.7 (A), R79.1
unnamed: OK3.7 (A), R59.1
unnamed: OK4.1 (A), R60.1
unnamed: OK4.3 (A), R61.1
unnamed: OK4.5 (A), R62.1
unnamed: OK4.7 (A), R63.1
RELAY_DRV_OUT_1: CON3.A2, IC6.18 (O1)
RELAY_DRV_OUT_2: CON3.B2, IC6.17 (O2)
RELAY_DRV_OUT_3: CON3.A3, IC6.16 (O3)
RELAY_DRV_OUT_4: CON3.B3, IC6.15 (O4)
RELAY_DRV_OUT_5: CON3.A4, IC6.14 (O5)
RELAY_DRV_OUT_6: CON3.B4, IC6.13 (O6)
RELAY_DRV_OUT_7: CON3.A5, IC6.12 (O7)
RELAY_DRV_OUT_8: CON3.B5, IC6.11 (O8)
RELAY_DRV_OUT_9: CON3.A6, IC7.18 (O1)
RELAY_DRV_OUT_10: CON3.B6, IC7.17 (O2)
RELAY_DRV_OUT_11: CON3.A7, IC7.16 (O3)
RELAY_DRV_OUT_12: CON3.B7, IC7.15 (O4)
RELAY_DRV_OUT_13: CON3.A8, IC7.14 (O5)
RELAY_DRV_OUT_14: CON3.B8, IC7.13 (O6)
RELAY_DRV_OUT_15: CON3.A9, IC7.12 (O7)
RELAY_DRV_OUT_16: CON3.B9, IC7.11 (O8)
RELAY_DRV_OUT_17: CON3.A10, IC8.18 (O1)
RELAY_DRV_OUT_18: CON3.B10, IC8.17 (O2)
RELAY_DRV_OUT_19: CON3.A11, IC8.16 (O3)
RELAY_DRV_OUT_20: CON3.B11, IC8.15 (O4)
RELAY_DRV_OUT_21: CON3.A12, IC8.14 (O5)
RELAY_DRV_OUT_22: CON3.B12, IC8.13 (O6)
RELAY_DRV_OUT_23: CON3.A13, IC8.12 (O7)
RELAY_DRV_OUT_24: CON3.B13, IC8.11 (O8)

Notes on the sheet:
继电器隔离驱动

Parts:
C78, C79, C80, C81, C83, C84, C85, C86, C87, C88, C89, C90, C91, C93, C94, C95, C96, C97, C98, C99, C100, C101: 10nF/50V; C0603
C82, C92: 100uF/6.3V 5x5.8; UD-5X5,8_NICHICON
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21: 1N4148; MINI_MELF(LL-34)
OK7, OK8, OK9, OK10, OK11: TLP283-4; MINI-FLAT-16
R88, R89, R90, R91, R92, R93, R94, R95, R100, R101, R102, R103, R104, R105, R106, R107, R112, R113, R114, R115, R116, R117, R118, R119, R124, R125, R126, R127, R128, R129, R130, R131, R136, R137, R138, R139, R140, R141, R142, R143: 2.2k; R1206
R96, R97, R98, R99, R108, R109, R110, R111, R120, R121, R122, R123, R132, R133, R134, R135, R144, R145, R146, R147: 10K; R0603
X2: FFKDS/V1-5.08_FIRST; FFKDS/V1-5,08-1_FIRST
X3, X4, X5, X6, X7, X8, X9, X10, X11, X12, X13, X14, X15, X16, X17, X18, X19, X20, X21, X22, X23, X24, X25, X26, X27, X28, X29, X30, X31, X32, X33, X34, X35, X36, X37, X38, X39, X40: FFKDS/V1-5.08_MIDDLE; FFKDS/V1-5,08-1_MIDDLE
X41: FFKDS/V1-5.08_LAST; FFKDS/V1-5,08-1_LAST

Connections:
+3V3: C82.+, C83.1, C92.+, C93.1, R96.2, R97.2, R98.2, R99.2, R108.2, R109.2, R110.2, R111.2, R120.2, R121.2, R122.2, R123.2, R132.2, R133.2, R134.2, R135.2, R144.2, R145.2, R146.2, R147.2; also elsewhere on the board
DIN1: C78.1, OK7.16 (COL), R96.1; also elsewhere on the board
DIN2: C79.1, OK7.14 (COL), R97.1; also elsewhere on the board
DIN3: C80.1, OK7.12 (COL), R98.1; also elsewhere on the board
DIN4: C81.1, OK7.10 (COL), R99.1; also elsewhere on the board
DIN5: C84.1, OK8.16 (COL), R108.1; also elsewhere on the board
DIN6: C85.1, OK8.14 (COL), R109.1; also elsewhere on the board
DIN7: C86.1, OK8.12 (COL), R110.1; also elsewhere on the board
DIN8: C87.1, OK8.10 (COL), R111.1; also elsewhere on the board
DIN9: C88.1, OK9.16 (COL), R120.1; also elsewhere on the board
DIN10: C89.1, OK9.14 (COL), R121.1; also elsewhere on the board
DIN11: C90.1, OK9.12 (COL), R122.1; also elsewhere on the board
DIN12: C91.1, OK9.10 (COL), R123.1; also elsewhere on the board
DIN13: C94.1, OK10.16 (COL), R132.1; also elsewhere on the board
DIN14: C95.1, OK10.14 (COL), R133.1; also elsewhere on the board
DIN15: C96.1, OK10.12 (COL), R134.1; also elsewhere on the board
DIN16: C97.1, OK10.10 (COL), R135.1; also elsewhere on the board
DIN17: C98.1, OK11.16 (COL), R144.1; also elsewhere on the board
DIN18: C99.1, OK11.14 (COL), R145.1; also elsewhere on the board
DIN19: C100.1, OK11.12 (COL), R146.1; also elsewhere on the board
DIN20: C101.1, OK11.10 (COL), R147.1; also elsewhere on the board
GND: C78.2, C79.2, C80.2, C81.2, C82.-, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C90.2, C91.2, C92.-, C93.2, C94.2, C95.2, C96.2, C97.2, C98.2, C99.2, C100.2, C101.2, OK7.9 (EMIT), OK7.11 (EMIT), OK7.13 (EMIT), OK7.15 (EMIT), OK8.9 (EMIT), OK8.11 (EMIT), OK8.13 (EMIT), OK8.15 (EMIT), OK9.9 (EMIT), OK9.11 (EMIT), OK9.13 (EMIT), OK9.15 (EMIT), OK10.9 (EMIT), OK10.11 (EMIT), OK10.13 (EMIT), OK10.15 (EMIT), OK11.9 (EMIT), OK11.11 (EMIT), OK11.13 (EMIT), OK11.15 (EMIT); also elsewhere on the board
unnamed: D2.C, OK7.1 (A), R88.2
unnamed: D2.A, OK7.2 (C), R89.2
unnamed: D3.C, OK7.3 (A), R90.2
unnamed: D3.A, OK7.4 (C), R91.2
unnamed: D4.C, OK7.5 (A), R92.2
unnamed: D4.A, OK7.6 (C), R93.2
unnamed: D5.C, OK7.7 (A), R94.2
unnamed: D5.A, OK7.8 (C), R95.2
unnamed: D6.C, OK8.1 (A), R100.2
unnamed: D6.A, OK8.2 (C), R101.2
unnamed: D7.C, OK8.3 (A), R102.2
unnamed: D7.A, OK8.4 (C), R103.2
unnamed: D8.C, OK8.5 (A), R104.2
unnamed: D8.A, OK8.6 (C), R105.2
unnamed: D9.C, OK8.7 (A), R106.2
unnamed: D9.A, OK8.8 (C), R107.2
unnamed: D10.C, OK9.1 (A), R112.2
unnamed: D10.A, OK9.2 (C), R113.2
unnamed: D11.C, OK9.3 (A), R114.2
unnamed: D11.A, OK9.4 (C), R115.2
unnamed: D12.C, OK9.5 (A), R116.2
unnamed: D12.A, OK9.6 (C), R117.2
unnamed: D13.C, OK9.7 (A), R118.2
unnamed: D13.A, OK9.8 (C), R119.2
unnamed: R88.1, X2.1@1, X2.2@1
unnamed: R89.1, X3.1@1, X3.2@1
unnamed: R112.1, X18.1@1, X18.2@1
unnamed: R113.1, X19.1@1, X19.2@1
unnamed: R114.1, X20.1@1, X20.2@1
unnamed: R115.1, X21.1@1, X21.2@1
unnamed: R116.1, X22.1@1, X22.2@1
unnamed: R117.1, X23.1@1, X23.2@1
unnamed: R118.1, X24.1@1, X24.2@1
unnamed: R119.1, X25.1@1, X25.2@1
unnamed: R100.1, X10.1@1, X10.2@1
unnamed: R101.1, X11.1@1, X11.2@1
unnamed: R102.1, X12.1@1, X12.2@1
unnamed: R103.1, X13.1@1, X13.2@1
unnamed: R104.1, X14.1@1, X14.2@1
unnamed: R105.1, X15.1@1, X15.2@1
unnamed: R106.1, X16.1@1, X16.2@1
unnamed: R107.1, X17.1@1, X17.2@1
unnamed: R90.1, X4.1@1, X4.2@1
unnamed: R91.1, X5.1@1, X5.2@1
unnamed: R92.1, X6.1@1, X6.2@1
unnamed: R93.1, X7.1@1, X7.2@1
unnamed: R94.1, X8.1@1, X8.2@1
unnamed: R95.1, X9.1@1, X9.2@1
unnamed: D14.C, OK10.1 (A), R124.2
unnamed: D14.A, OK10.2 (C), R125.2
unnamed: D15.C, OK10.3 (A), R126.2
unnamed: D15.A, OK10.4 (C), R127.2
unnamed: D16.C, OK10.5 (A), R128.2
unnamed: D16.A, OK10.6 (C), R129.2
unnamed: D17.C, OK10.7 (A), R130.2
unnamed: D17.A, OK10.8 (C), R131.2
unnamed: R124.1, X26.1@1, X26.2@1
unnamed: R125.1, X27.1@1, X27.2@1
unnamed: R126.1, X28.1@1, X28.2@1
unnamed: R127.1, X29.1@1, X29.2@1
unnamed: R128.1, X30.1@1, X30.2@1
unnamed: R129.1, X31.1@1, X31.2@1
unnamed: R130.1, X32.1@1, X32.2@1
unnamed: R131.1, X33.1@1, X33.2@1
unnamed: D18.C, OK11.1 (A), R136.2
unnamed: D18.A, OK11.2 (C), R137.2
unnamed: D19.C, OK11.3 (A), R138.2
unnamed: D19.A, OK11.4 (C), R139.2
unnamed: D20.C, OK11.5 (A), R140.2
unnamed: D20.A, OK11.6 (C), R141.2
unnamed: D21.C, OK11.7 (A), R142.2
unnamed: D21.A, OK11.8 (C), R143.2
unnamed: R136.1, X34.1@1, X34.2@1
unnamed: R137.1, X35.1@1, X35.2@1
unnamed: R138.1, X36.1@1, X36.2@1
unnamed: R139.1, X37.1@1, X37.2@1
unnamed: R140.1, X38.1@1, X38.2@1
unnamed: R141.1, X39.1@1, X39.2@1
unnamed: R142.1, X40.1@1, X40.2@1
unnamed: R143.1, X41.1@1, X41.2@1

Notes on the sheet:
开关量隔离输入部分

Parts:
C102, C125, C144, C159: 47uF/6.3V 5x5.8; UD-5X5,8_NICHICON
C103: 10nF/50V; C0603
C104, C106, C108, C110, C111, C112, C113, C114, C119, C127, C129, C130, C131, C132, C133, C142, C145, C146, C147, C148, C153: 100nF/50V; C0603
C105, C124, C143, C154: 10uF/16V; C0603
C107: 1000uF/16V_M10*16; E3,5-10
C109: 220uF/16V_M10*16; E3,5-10
C115, C116, C117, C118, C134, C135, C136, C137, C149, C150, C151, C152: 30pF/50V; C0603
C120, C121, C122, C123, C138, C139, C140, C141, C155, C156, C157, C158: 1nF/50V; C0603
C126: 2200uF/50V_M16*25; E7,5-16
C128: CPOL-EUTT5D11; TT5D11
D22, D31: 1N4007; SMA-DO214AC
D23, D24, D25, D26, D27, D28, D29, D30, D32, D33, D34, D35: 1N4148; MINI_MELF(LL-34)
DB1, DB2: KBP2005G; KBP2005
F4, F5: RXEF110
HS1: HEATSINK; HS_TO-220-B
IC9: LM4040AIM3X-2.5; SOT23-3
IC10: LM1117IDTX-3.3; TO252
IC11, IC13, IC14, IC15: SGM8584XS14; SOIC-14
IC12: LM78M24; 78XXS
L8, L9, L11, L12: 10uH; L0603
L10: 100R/100MHz; L0805
R148, R154, R155, R156, R157, R179, R180, R181, R182, R203, R204, R205, R206: 10k; R0603
R149: 10K; R0603
R150, R151, R152, R153, R175, R176, R177, R178, R199, R200, R201, R202: 120R/0.1%; R1206
R158, R159, R160, R161, R183, R184, R185, R186, R207, R208, R209, R210: 5.11k/1%; R0603
R162, R163, R164, R165, R187, R188, R189, R190, R211, R212, R213, R214: 124k/1%; R0603
R166, R167, R168, R169, R191, R192, R193, R194, R215, R216, R217, R218: 1k/1%; R0603
R170, R171, R172, R173, R195, R196, R197, R198, R219, R220, R221, R222: 1k; R0603
R174: 20K; R1206
X42, X44, X45, X46, X47, X48, X49, X50, X51, X52, X53, X54, X55, X56, X57, X59, X60, X61, X62, X63, X64, X65, X66, X67, X68, X71, X72, X73, X74, X75, X76, X77, X78, X79, X80, X82, X83, X84, X85, X86, X87, X89: FFKDS/V1-5.08_MIDDLE; FFKDS/V1-5,08-1_MIDDLE
X43, X69, X81: FFKDS/V1-5.08_LAST; FFKDS/V1-5,08-1_LAST
X58, X70, X88: FFKDS/V1-5.08_FIRST; FFKDS/V1-5,08-1_FIRST
XT3, XT4: FFKDS/V1-5.08-2

Connections:
ADCIN0: C120.1, R170.2; also elsewhere on the board
ADCIN1: C121.1, R171.2; also elsewhere on the board
ADCIN2: C122.1, R172.2; also elsewhere on the board
ADCIN3: C123.1, R173.2; also elsewhere on the board
ADCIN4: C138.1, R195.2; also elsewhere on the board
ADCIN5: C139.1, R196.2; also elsewhere on the board
ADCIN6: C140.1, R197.2; also elsewhere on the board
ADCIN7: C141.1, R198.2; also elsewhere on the board
ADCIN8: C155.1, R219.2; also elsewhere on the board
ADCIN9: C156.1, R220.2; also elsewhere on the board
ADCIN10: C157.1, R221.2; also elsewhere on the board
ADCIN11: C158.1, R222.2; also elsewhere on the board
AGND: C102.-, C103.2, C104.2, C105.2, C106.2, C107.-, C108.2, C109.-, C110.2, C111.2, C112.2, C113.2, C114.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.-, C126.-, C127.2, C128.-, C129.2, C130.2, C131.2, C132.2, C133.2, C138.2, C139.2, C140.2, C141.2, C142.2, C143.2, C144.-, C145.2, C146.2, C147.2, C148.2, C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C159.-, DB1.DC- (-), DB2.DC- (-), IC9.2 (A), IC10.3 (VSS), IC11.11 (V-), IC12.GND, IC13.11 (V-), IC14.11 (V-), IC15.11 (V-), L10.2, R149.2, R150.1, R151.1, R152.1, R153.1, R162.1, R163.1, R164.1, R165.1, R174.2, R175.1, R176.1, R177.1, R178.1, R187.1, R188.1, R189.1, R190.1, R199.1, R200.1, R201.1, R202.1, R211.1, R212.1, R213.1, R214.1, X43.1@1, X43.2@1, X45.1@1, X45.2@1, X47.1@1, X47.2@1, X49.1@1, X49.2@1, X51.1@1, X51.2@1, X53.1@1, X53.2@1, X55.1@1, X55.2@1, X57.1@1, X57.2@1, X70.1@1, X70.2@1, X71.1@1, X71.2@1, X72.1@1, X72.2@1, X73.1@1, X73.2@1, X74.1@1, X74.2@1, X75.1@1, X75.2@1, X76.1@1, X76.2@1, X77.1@1, X77.2@1, X78.1@1, X78.2@1, X79.1@1, X79.2@1, X80.1@1, X80.2@1, X81.1@1, X81.2@1, X83.1@1, X83.2@1, X85.1@1, X85.2@1, X87.1@1, X87.2@1, X89.1@1, X89.2@1; also elsewhere on the board
GND: L10.1; also elsewhere on the board
unnamed: C104.1, C105.1, IC14.4 (V+), L8.1, R148.2
unnamed: C119.1, C124.1, IC11.4 (V+), L9.2
unnamed: C153.1, C154.1, IC15.4 (V+), L12.2
unnamed: C142.1, C143.1, IC13.4 (V+), L11.2
unnamed: DB2.AC2 (A2), XT4.2@1, XT4.2@2
unnamed: DB2.AC1 (A1), F4.2
unnamed: DB1.AC2 (A2), XT3.2@1, XT3.2@2
unnamed: DB1.AC1 (A1), F5.2
unnamed: C128.+, C133.1, D31.A, IC12.OUT, X58.1@1, X58.2@1, X59.1@1, X59.2@1, X60.1@1, X60.2@1, X61.1@1, X61.2@1, X62.1@1, X62.2@1, X63.1@1, X63.2@1, X64.1@1, X64.2@1, X65.1@1, X65.2@1, X66.1@1, X66.2@1, X67.1@1, X67.2@1, X68.1@1, X68.2@1, X69.1@1, X69.2@1
unnamed: F4.1, XT4.1@1, XT4.1@2
unnamed: F5.1, XT3.1@1, XT3.1@2
unnamed: D23.C, R150.2, R154.1
unnamed: C111.1, IC11.3 (+IN), R154.2
unnamed: D23.A, X42.1@1, X42.2@1
unnamed: C115.2, IC11.2 (-IN), R158.1, R162.2, R166.1
unnamed: D24.C, R151.2, R155.1
unnamed: C107.+, C108.1, D22.C, DB1.DC+ (+), IC10.1 (VIN), R149.1
unnamed: C112.1, IC11.5 (+IN), R155.2
unnamed: D24.A, X44.1@1, X44.2@1
unnamed: C116.2, IC11.6 (-IN), R159.1, R163.2, R167.1
unnamed: D25.C, R152.2, R156.1
unnamed: C113.1, IC11.10 (+IN), R156.2
unnamed: D25.A, X46.1@1, X46.2@1
unnamed: C117.2, IC11.9 (-IN), R160.1, R164.2, R168.2
unnamed: C126.+, C127.1, D31.C, DB2.DC+ (+), IC12.IN, R174.1
unnamed: D26.C, R153.2, R157.1
unnamed: C114.1, IC11.12 (+IN), R157.2
unnamed: D26.A, X48.1@1, X48.2@1
unnamed: C118.2, IC11.13 (-IN), R161.1, R165.2, R169.2
unnamed: C106.1, IC9.1 (C), IC14.3 (+IN), IC14.5 (+IN), IC14.10 (+IN), IC14.12 (+IN), R148.1
unnamed: D27.C, R175.2, R179.1
unnamed: C129.1, IC13.3 (+IN), R179.2
unnamed: D27.A, X50.1@1, X50.2@1
unnamed: C134.2, IC13.2 (-IN), R183.1, R187.2, R191.2
unnamed: IC14.8 (OUT), IC14.9 (-IN), R158.2, R159.2, R160.2, R161.2
unnamed: D28.C, R176.2, R180.1
unnamed: C130.1, IC13.5 (+IN), R180.2
unnamed: D28.A, X52.1@1, X52.2@1
unnamed: C135.2, IC13.6 (-IN), R184.1, R188.2, R192.2
unnamed: IC14.6 (-IN), IC14.7 (OUT), R183.2, R184.2, R185.2, R186.2
unnamed: D29.C, R177.2, R181.1
unnamed: C131.1, IC13.10 (+IN), R181.2
unnamed: D29.A, X54.1@1, X54.2@1
unnamed: C136.2, IC13.9 (-IN), R185.1, R189.2, R193.2
unnamed: IC14.1 (OUT), IC14.2 (-IN), R207.2, R208.2, R209.2, R210.2
unnamed: D30.C, R178.2, R182.1
unnamed: C132.1, IC13.12 (+IN), R182.2
unnamed: D30.A, X56.1@1, X56.2@1
unnamed: C137.2, IC13.13 (-IN), R186.1, R190.2, R194.2
unnamed: C115.1, IC11.1 (OUT), R166.2, R170.1
unnamed: D32.C, R199.2, R203.1
unnamed: C145.1, IC15.3 (+IN), R203.2
unnamed: D32.A, X82.1@1, X82.2@1
unnamed: C149.2, IC15.2 (-IN), R207.1, R211.2, R215.2
unnamed: C134.1, IC13.1 (OUT), R191.1, R195.1
unnamed: D33.C, R200.2, R204.1
unnamed: C146.1, IC15.5 (+IN), R204.2
unnamed: D33.A, X84.1@1, X84.2@1
unnamed: C150.2, IC15.6 (-IN), R208.1, R212.2, R216.1
unnamed: C149.1, IC15.1 (OUT), R215.1, R219.1
unnamed: D34.C, R201.2, R205.1
unnamed: C147.1, IC15.10 (+IN), R205.2
unnamed: D34.A, X86.1@1, X86.2@1
unnamed: C151.2, IC15.9 (-IN), R209.1, R213.2, R217.1
unnamed: C150.1, IC15.7 (OUT), R216.2, R220.1
unnamed: D35.C, R202.2, R206.1
unnamed: C148.1, IC15.12 (+IN), R206.2
unnamed: D35.A, X88.1@1, X88.2@1
unnamed: C152.2, IC15.13 (-IN), R210.1, R214.2, R218.1
unnamed: C151.1, IC15.8 (OUT), R217.2, R221.1
unnamed: C152.1, IC15.14 (OUT), R218.2, R222.1
unnamed: C135.1, IC13.7 (OUT), R192.1, R196.1
unnamed: C136.1, IC13.8 (OUT), R193.1, R197.1
unnamed: C137.1, IC13.14 (OUT), R194.1, R198.1
unnamed: C116.1, IC11.7 (OUT), R167.2, R171.1
unnamed: C117.1, IC11.8 (OUT), R168.1, R172.1
unnamed: C118.1, IC11.14 (OUT), R169.1, R173.1
VCCA_3V3: C102.+, C103.1, C109.+, C110.1, C125.+, C144.+, C159.+, D22.A, IC10.2 (VOUT), L8.2, L9.1, L11.1, L12.1; also elsewhere on the board
VREF_2.5V_ADC: IC14.13 (-IN), IC14.14 (OUT); also elsewhere on the board

Notes on the sheet:
温度变送器 PT100 -50~100度 4－20MA 杭州雪辰仪表 https://item.taobao.com/item.htm?spm=a230r.1.14.62.76bf523uB9S1q
LM4040AIM3X-2.5
12 路模拟量输入（4～20mA电流环）
KBE4825(D)(自带整流桥的型号) 初级工作电压：选择220V的 次级输出电压 24V 次级空载电压 26.9V 次级满载电流 625mA
24V 、0V 端子 为 4-20mA变送器供电。 每个变送器一对儿端子。 端子分为上下两排，上24V，下0V
KBE4825(D)
变压器BK-50VA： 定制 输入：380/220V 输出：24V/1A 独立绕组 6V/1A 独立绕组
6V AC In
24V AC In
自恢复保险
1.5A
